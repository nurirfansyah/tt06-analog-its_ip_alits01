v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1360 -1290 1360 -1260 {
lab=VGND}
C {devices/ipin.sym} 770 -1610 0 0 {name=p0 lab=clk}
C {devices/ipin.sym} 770 -1590 0 0 {name=p1 lab=ena}
C {devices/ipin.sym} 770 -1570 0 0 {name=p2 lab=rst_n}
C {devices/ipin.sym} 770 -1490 0 0 {name=p6 lab=ua[3]}
C {devices/ipin.sym} 770 -1470 0 0 {name=p7 lab=ua[4]}
C {devices/ipin.sym} 770 -1450 0 0 {name=p14 lab=ua[5]}
C {devices/ipin.sym} 770 -1430 0 0 {name=p9 lab=ua[6]}
C {devices/ipin.sym} 770 -1410 0 0 {name=p10 lab=ua[7]}
C {devices/ipin.sym} 770 -1370 0 0 {name=p12 lab=ui_in[1]}
C {devices/ipin.sym} 770 -1350 0 0 {name=p13 lab=ui_in[2]}
C {devices/ipin.sym} 770 -1330 0 0 {name=p8 lab=ui_in[3]}
C {devices/ipin.sym} 770 -1310 0 0 {name=p15 lab=ui_in[4]}
C {devices/ipin.sym} 770 -1290 0 0 {name=p16 lab=ui_in[5]}
C {devices/ipin.sym} 770 -1270 0 0 {name=p17 lab=ui_in[6]}
C {devices/ipin.sym} 770 -1250 0 0 {name=p18 lab=ui_in[7]}
C {devices/ipin.sym} 770 -1230 0 0 {name=p19 lab=uio_in[0]}
C {devices/ipin.sym} 770 -1210 0 0 {name=p20 lab=uio_in[1]}
C {devices/ipin.sym} 770 -1190 0 0 {name=p21 lab=uio_in[2]}
C {devices/ipin.sym} 770 -1170 0 0 {name=p22 lab=uio_in[3]}
C {devices/ipin.sym} 770 -1150 0 0 {name=p23 lab=uio_in[4]}
C {devices/ipin.sym} 770 -1130 0 0 {name=p24 lab=uio_in[5]}
C {devices/ipin.sym} 770 -1110 0 0 {name=p25 lab=uio_in[6]}
C {devices/ipin.sym} 770 -1090 0 0 {name=p26 lab=uio_in[7]}
C {devices/opin.sym} 890 -1610 0 0 {name=p27 lab=uio_oe[0]}
C {devices/opin.sym} 890 -1590 0 0 {name=p28 lab=uio_oe[1]}
C {devices/opin.sym} 890 -1570 0 0 {name=p29 lab=uio_oe[2]}
C {devices/opin.sym} 890 -1550 0 0 {name=p30 lab=uio_oe[3]}
C {devices/opin.sym} 890 -1530 0 0 {name=p31 lab=uio_oe[4]}
C {devices/opin.sym} 890 -1510 0 0 {name=p32 lab=uio_oe[5]}
C {devices/opin.sym} 890 -1490 0 0 {name=p33 lab=uio_oe[6]}
C {devices/opin.sym} 890 -1470 0 0 {name=p34 lab=uio_oe[7]}
C {devices/opin.sym} 890 -1430 0 0 {name=p36 lab=uo_out[1]}
C {devices/opin.sym} 890 -1410 0 0 {name=p37 lab=uo_out[2]}
C {devices/opin.sym} 890 -1390 0 0 {name=p38 lab=uo_out[3]}
C {devices/opin.sym} 890 -1370 0 0 {name=p39 lab=uo_out[4]}
C {devices/opin.sym} 890 -1350 0 0 {name=p40 lab=uo_out[5]}
C {devices/opin.sym} 890 -1330 0 0 {name=p41 lab=uo_out[6]}
C {devices/opin.sym} 890 -1310 0 0 {name=p42 lab=uo_out[7]}
C {devices/noconn.sym} 770 -1610 0 1 {name=l1}
C {devices/noconn.sym} 770 -1590 0 1 {name=l2}
C {devices/noconn.sym} 770 -1570 0 1 {name=l3}
C {devices/noconn.sym} 770 -1490 0 1 {name=l7}
C {devices/noconn.sym} 770 -1430 0 1 {name=l8}
C {devices/noconn.sym} 770 -1390 0 1 {name=l25}
C {devices/noconn.sym} 770 -1370 0 1 {name=l26}
C {devices/noconn.sym} 770 -1350 0 1 {name=l27}
C {devices/noconn.sym} 770 -1330 0 1 {name=l28}
C {devices/noconn.sym} 770 -1310 0 1 {name=l29}
C {devices/noconn.sym} 770 -1290 0 1 {name=l30}
C {devices/noconn.sym} 770 -1270 0 1 {name=l31}
C {devices/noconn.sym} 770 -1250 0 1 {name=l32}
C {devices/noconn.sym} 770 -1230 0 1 {name=l33}
C {devices/noconn.sym} 770 -1210 0 1 {name=l34}
C {devices/noconn.sym} 770 -1190 0 1 {name=l35}
C {devices/noconn.sym} 770 -1170 0 1 {name=l36}
C {devices/noconn.sym} 770 -1150 0 1 {name=l37}
C {devices/noconn.sym} 770 -1130 0 1 {name=l38}
C {devices/noconn.sym} 770 -1110 0 1 {name=l39}
C {devices/noconn.sym} 770 -1090 0 1 {name=l40}
C {devices/noconn.sym} 890 -1610 0 0 {name=l41}
C {devices/noconn.sym} 890 -1590 0 0 {name=l42}
C {devices/noconn.sym} 890 -1570 0 0 {name=l43}
C {devices/noconn.sym} 890 -1550 0 0 {name=l44}
C {devices/noconn.sym} 890 -1530 0 0 {name=l45}
C {devices/noconn.sym} 890 -1510 0 0 {name=l46}
C {devices/noconn.sym} 890 -1490 0 0 {name=l47}
C {devices/noconn.sym} 890 -1470 0 0 {name=l48}
C {devices/noconn.sym} 890 -1430 0 0 {name=l50}
C {devices/noconn.sym} 890 -1410 0 0 {name=l51}
C {devices/noconn.sym} 890 -1390 0 0 {name=l52}
C {devices/noconn.sym} 890 -1370 0 0 {name=l53}
C {devices/noconn.sym} 890 -1350 0 0 {name=l54}
C {devices/noconn.sym} 890 -1330 0 0 {name=l55}
C {devices/noconn.sym} 890 -1310 0 0 {name=l56}
C {devices/iopin.sym} 900 -1270 0 0 {name=p45 lab=uio_out[0]}
C {devices/noconn.sym} 900 -1270 0 0 {name=l9}
C {devices/iopin.sym} 900 -1250 0 0 {name=p46 lab=uio_out[1]}
C {devices/noconn.sym} 900 -1250 0 0 {name=l10}
C {devices/iopin.sym} 900 -1230 0 0 {name=p47 lab=uio_out[2]}
C {devices/noconn.sym} 900 -1230 0 0 {name=l11}
C {devices/iopin.sym} 900 -1210 0 0 {name=p48 lab=uio_out[3]}
C {devices/noconn.sym} 900 -1210 0 0 {name=l12}
C {devices/iopin.sym} 900 -1190 0 0 {name=p49 lab=uio_out[4]}
C {devices/noconn.sym} 900 -1190 0 0 {name=l13}
C {devices/iopin.sym} 900 -1170 0 0 {name=p50 lab=uio_out[5]}
C {devices/noconn.sym} 900 -1170 0 0 {name=l14}
C {devices/iopin.sym} 900 -1150 0 0 {name=p51 lab=uio_out[6]}
C {devices/noconn.sym} 900 -1150 0 0 {name=l15}
C {devices/iopin.sym} 900 -1130 0 0 {name=p52 lab=uio_out[7]}
C {devices/noconn.sym} 900 -1130 0 0 {name=l16}
C {devices/noconn.sym} 770 -1450 0 1 {name=l17}
C {devices/noconn.sym} 770 -1470 0 1 {name=l18}
C {devices/noconn.sym} 770 -1410 0 1 {name=l4}
C {devices/ipin.sym} 1270 -1460 0 0 {name=p3 lab=ua[0]}
C {devices/ipin.sym} 1270 -1380 0 0 {name=p4 lab=ua[1]}
C {devices/ipin.sym} 1270 -1350 0 0 {name=p11 lab=ui_in[0]}
C {devices/opin.sym} 1430 -1460 0 0 {name=p35 lab=uo_out[0]}
C {devices/opin.sym} 1430 -1380 0 0 {name=p5 lab=ua[2]}
C {devices/iopin.sym} 1360 -1260 1 0 {name=p44 lab=VGND}
C {devices/iopin.sym} 1360 -1530 1 1 {name=p43 lab=VPWR}
C {devices/noconn.sym} 1430 -1460 0 0 {name=l5}
C {devices/noconn.sym} 1430 -1380 0 0 {name=l6}
C {devices/noconn.sym} 1360 -1530 0 0 {name=l19}
C {devices/noconn.sym} 1360 -1290 0 0 {name=l20}
C {devices/noconn.sym} 1270 -1460 0 1 {name=l21}
C {devices/noconn.sym} 1270 -1380 0 1 {name=l22}
C {devices/noconn.sym} 1270 -1350 0 1 {name=l23}
